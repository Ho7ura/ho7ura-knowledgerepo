# Keil uVision project IT_OCP.uvprojx, settings and files
target IT_OCP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IT_OCP +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/ECW;../User/SYSTEM/delay;../User/SYSTEM/sys;../User/SYSTEM/usart
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../User/ECW/: ecw.c
    ../User/SYSTEM/sys/: sys.c
    ../User/SYSTEM/delay/: delay.c
    ../Core/Src/: main.c gpio.c adc.c dac.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c iwdg.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_iwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
